# Keil uVision project STM32F1_CANFD_MCP2518FD.uvprojx, settings and files
target CANFD-TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CANFD_TEST +hex
  AfterMake: fromelf.exe --elf -o  out.elf CANFD_TEST.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\User;..\Driver;..\Common\CMSIS\CM3\CoreSupport;..\Common\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Common\STM32F10x_StdPeriph_Driver\inc;..\Driver\canfdspi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Setup
    ../Common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c dev_can.c
  group Driver
    ../Driver/canfdspi/: drv_canfdspi_api.c
    ../Driver/: bsp_usart.c delay.c sys_phr.c drv_spi_mcp2517fd.c sys_timer.c
  group CMSIS
    ../Common/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
